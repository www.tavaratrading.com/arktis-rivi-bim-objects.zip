Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-07-21T12:37:01+02:00
Written by: ODA SDAI 22.12
Made in: 23.0.11.19 - Exporter 23.0.11.19 - Alternate UI 23.0.11.19

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcFurnishingElement: RIVI Stool A 62x62:Rivi Stool A 62x62, RIVI Stool A 62x62:Rivi Stool A 62x62:252130
In: Level 1
Type - Material: Default upholstery (2), Default legs (8)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Arktis
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: Rivi Stool A 62x62
